## boards/shields/knot-remodel/Kconfig.defconfig
```kconfig
if SHIELD_KNOT-REMODEL

    config ZMK_KEYBOARD_NAME
        default "knot-remodel"
        
endif
```
